<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_1</value></param>
<param><key>value</key><value>915000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_2</value></param>
<param><key>value</key><value>2480000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>IEEE_802_15_4_CustomBlocks_Beacon</key>
<param><key>id</key><value>IEEE_802_15_4_CustomBlocks_Beacon_0</value></param>
<param><key>interval</key><value>128</value></param>
<param><key>total_msg</key><value>-1</value></param>
</block>
<block>
<key>IEEE_802_15_4_CustomBlocks_MAC_Coordinator</key>
<param><key>id</key><value>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</value></param>
<param><key>coord_addr</key><value>0x3344</value></param>
<param><key>coord_pan</key><value>0x1aaa</value></param>
<param><key>dst_pan</key><value>0x1aaa</value></param>
<param><key>fcf</key><value>0x8841</value></param>
<param><key>seq_nr</key><value>0</value></param>
<param><key>superframe_len</key><value>10000</value></param>
<param><key>threshold</key><value>9000</value></param>
<param><key>total_slots</key><value>128</value></param>
</block>
<block>
<key>PHY_Receiver</key>
<param><key>id</key><value>PHY_Receiver_0</value></param>
</block>
<block>
<key>PHY_Transmitter</key>
<param><key>id</key><value>PHY_Transmitter_0_0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq_1</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0.75</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>pdu_length</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>center_freq_1</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0.75</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_Beacon_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</sink_block_id><source_key>signal out</source_key><sink_key>beacon signal in</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</source_block_id><sink_block_id>PHY_Transmitter_0_0</sink_block_id><source_key>mac out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>PHY_Receiver_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</sink_block_id><source_key>rxout</source_key><sink_key>request in</sink_key></connection>
<connection><source_block_id>PHY_Transmitter_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>PHY_Receiver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
