<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_1</value></param>
<param><key>value</key><value>915000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq_2</value></param>
<param><key>value</key><value>2480000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>IEEE_802_15_4_CustomBlocks_Beacon</key>
<param><key>id</key><value>IEEE_802_15_4_CustomBlocks_Beacon_0</value></param>
<param><key>interval</key><value>128</value></param>
<param><key>total_msg</key><value>-1</value></param>
</block>
<block>
<key>IEEE_802_15_4_CustomBlocks_MAC_Coordinator</key>
<param><key>id</key><value>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</value></param>
<param><key>coord_addr</key><value>0x3344</value></param>
<param><key>coord_pan</key><value>0x1aaa</value></param>
<param><key>dst_pan</key><value>0x1aaa</value></param>
<param><key>fcf</key><value>0x8841</value></param>
<param><key>seq_nr</key><value>0</value></param>
<param><key>superframe_len</key><value>128</value></param>
<param><key>threshold</key><value>7</value></param>
<param><key>total_slots</key><value>128</value></param>
</block>
<block>
<key>IEEE_802_15_4_CustomBlocks_MAC_Receiver</key>
<param><key>id</key><value>IEEE_802_15_4_CustomBlocks_MAC_Receiver_0</value></param>
<param><key>coord_addr</key><value>0x3344</value></param>
<param><key>coord_pan</key><value>0x1aaa</value></param>
<param><key>dst_addr</key><value>0xffff</value></param>
<param><key>dst_pan</key><value>0x1aaa</value></param>
<param><key>fcf</key><value>0x8841</value></param>
<param><key>seq_nr</key><value>0</value></param>
<param><key>src_addr</key><value>0x5566</value></param>
<param><key>src_pan</key><value>0x1aaa</value></param>
</block>
<block>
<key>IEEE_802_15_4_CustomBlocks_MAC_Sender</key>
<param><key>id</key><value>IEEE_802_15_4_CustomBlocks_MAC_Sender_0</value></param>
<param><key>coord_addr</key><value>0x3344</value></param>
<param><key>coord_pan</key><value>0x1aaa</value></param>
<param><key>dst_addr</key><value>0x5566</value></param>
<param><key>dst_pan</key><value>0x1aaa</value></param>
<param><key>fcf</key><value>0x8841</value></param>
<param><key>seq_nr</key><value>0</value></param>
<param><key>src_addr</key><value>0x6677</value></param>
<param><key>src_pan</key><value>0x1aaa</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value>localhost</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_Beacon_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</sink_block_id><source_key>signal out</source_key><sink_key>beacon signal in</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Sender_0</sink_block_id><source_key>mac out</source_key><sink_key>signal in</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_MAC_Receiver_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_MAC_Receiver_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_MAC_Sender_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Coordinator_0</sink_block_id><source_key>mac out</source_key><sink_key>request in</sink_key></connection>
<connection><source_block_id>IEEE_802_15_4_CustomBlocks_MAC_Sender_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Receiver_0</sink_block_id><source_key>mac out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>IEEE_802_15_4_CustomBlocks_MAC_Sender_0</sink_block_id><source_key>pdus</source_key><sink_key>message in</sink_key></connection>
</flow_graph>
